# Keil uVision project keyControlLed.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: keyControlLed +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F411xE,USE_STDPERIPH_DRIVER
  c include: ..\Core;..\StdPeriphDriver\inc;..\StdPeriphDriver;..\BSP\bsp_led;..\BSP\bsp_key;..\OS\FreeRTOS\include;..\OS\FreeRTOS\portable\MemMang;..\OS\FreeRTOS\portable\RVDS\ARM_CM4F;..\Application
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Core
    ../Core/: core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h startup_stm32f411xe.s stm32f4xx.h system_stm32f4xx.h
  group Driver
    ../StdPeriphDriver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
    ../StdPeriphDriver/: drv_gpio.c
  group Bsp
    ../BSP/bsp_led/: bsp_led.c
    ../BSP/bsp_key/: bsp_key.c
  group FreeRTOS
    ../OS/FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../OS/FreeRTOS/portable/MemMang/: heap_4.c
    ../OS/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group App
    ../Application/: FreeRTOSConfig.h main.c main.h stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h system_stm32f4xx.c app_task.c
